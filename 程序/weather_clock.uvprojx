# Keil uVision project weather_clock.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: weather_clock +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\Hardware;.\System;.\App;.\Assets;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --no_remove
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USER
    ./user/: main.c stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: Lcd_Driver.c GUI.c esp8266.c DHT11.c esp8266.h GUI.h LCD_Config.h Lcd_Driver.h
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_spi.c
  group System
    ./System/: delay.c rtc.c Serial.c delay.h Serial.h rtc.h
  group App
    ./App/: Boot_Screen.c Boot_Screen.h QDTFT.c QDTFT.h UI_Config.h cw_data.c cw_data.h screen_data.c screen_data.h debug.c debug.h
  group Assets
    ./Assets/: Font.h UI_Picture.h Pet_Anim.h
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h stm32f10x.h stm32f10x_conf.h platform_config.h
software components: CMSIS:CORE 5.0.1
